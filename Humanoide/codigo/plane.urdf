Commit message: introduccion nuevo entorno

File: Humanoide/codigo/plane.urdf (robot description, URDF)
Before this commit: robot plane, 1 links, 0 joints
Links:
- link planeLink: geometry collision box size=30 30 10; visual mesh filename=cubo1m.obj scale=1 1 1
